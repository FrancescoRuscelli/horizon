Commit message: updated limits

File: horizon/examples/urdf/cart_pole.urdf (robot description, URDF)
Before this commit: robot cart_pole, 5 links, 4 joints
Joints:
- joint pole_joint: limit lower=-3.1415 upper=3.1415 effort=0 velocity=100 -> lower=-6.283 upper=6.283 effort=0 velocity=100
